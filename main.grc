options:
  parameters:
    generate_options: qt_gui
    id: main
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '128'
    vlen: '2'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./sample.iq
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: byte
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
